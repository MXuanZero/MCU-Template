# Keil uVision project GD32F303-Porject.uvprojx, settings and files
target GD32F30X_HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303-Porject +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,DEF_KEIL_CMSIS_CORE=1,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c include: ..\lib\gd32\CMSIS;..\lib\gd32\CMSIS\GD\GD32F30x\Include;..\lib\gd32\GD32F30x_standard_peripheral\Include;..\lib\segger_rtt\RTT;..\lib\segger_rtt\Config;..\drv\;..\src\app;..\src\bsp;..\src\core;..\src\dbg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../lib/gd32/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Source/Core
    ../src/core/: gd32f30x_it.c main.c sys.c
  group Source/Dbg
    ../src/dbg/: dbg.c
  group Librarys/GD32F30x
    ../lib/gd32/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
    ../lib/gd32/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Librarys/SEGGER_RTT
    ../lib/segger_rtt/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
