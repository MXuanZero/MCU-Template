# Keil uVision project AT32F421.uvprojx, settings and files
target AT32F421 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.6
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F421 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\lib\at32\inc;..\lib\cmsis\cm4\core_support;..\lib\cmsis\cm4\device_support;..\lib\ctrl-sdk;..\src\app;..\src\bsp;..\src\core;..\src\dbg
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../lib/cmsis/cm4/device_support/startup/mdk/: startup_at32f421.s
    ../lib/cmsis/cm4/device_support/: system_at32f421.c
  group Sources/Bsp
    ../src/bsp/: at32f421_board.c nvic.c delay.c uart.c
  group Sources/Core
    ../src/core/: at32f421_clock.c at32f421_int.c main.c
  group Sources/Dbg
    ../src/dbg/: dbg.c vofa.c
  group Librarys/AT32F421
    ../lib/at32/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group Librarys/Ctrl-Sdk
    ../lib/ctrl-sdk/: hal_ccp_recv.c lib_assert.c lib_fsm.c lib_list.c lib_loop_task.c lib_queue.c lib_simple_buffer.c lib_stack.c lib_tick.c lib_timer.c lib_utils.c math_base.c math_filter.c math_pid.c hal_ccp_prot.c lib_assert_prot.c lib_tick_prot.c
